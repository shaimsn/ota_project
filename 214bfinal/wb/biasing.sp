*Matthew Meza
*Biasing
.include /usr/class/ee214b/hspice/ee214b_hspice.sp
